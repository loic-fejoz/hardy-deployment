options:
  parameters:
    author: F4JXQ
    description: UDP GFSK 9600 Transceiver with G3RUH Scrambling, NRZ-I and UDP Socket Interface
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: udp_gfsk
    output_language: python
    title: UDP_GFSK
  states: {}

blocks:
- name: UDP_HOST_RX
  id: variable
  parameters:
    comment: UDP Host destination for RADIANT
    value: '"127.0.0.1"'
  states: {}
- name: UDP_PORT_RX
  id: variable
  parameters:
    comment: UDP Port for RX output to RADIANT
    value: '52002'
  states: {}
- name: UDP_PORT_TX
  id: variable
  parameters:
    comment: UDP Port for TX input
    value: '52001'
  states: {}
- name: access_code
  id: variable
  parameters:
    comment: Sync Word (0x352E / 16 bits)
    value: '"0011010100101110"'
  states: {}
- name: baud_rate
  id: variable
  parameters:
    comment: Symbol/baud rate for GFSK
    value: '9600'
  states: {}
- name: bt
  id: variable
  parameters:
    comment: Gaussian filter BT factor (0.3 to 0.5)
    value: '0.5'
  states: {}
- name: deviation
  id: variable
  parameters:
    comment: Frequency deviation (2.4 kHz for GFSK 9600)
    value: '2400'
  states: {}
- name: freq_shift
  id: variable
  parameters:
    comment: Frequency shift (LO offset) to avoid SDR DC spike and 1/f noise (Hz)
    value: '50000'
  states: {}
- name: hdr_format_rx
  id: variable
  parameters:
    comment: 'Header format RX: 16-bit length (Access Code stripped by Correlator)'
    value: digital.header_format_default("", 0, 1)
  states: {}
- name: hdr_format_tx
  id: variable
  parameters:
    comment: 'Header format TX: Sync Word + 16-bit length'
    value: digital.header_format_default(access_code, 0, 1)
  states: {}
- name: rf_freq
  id: variable
  parameters:
    comment: RF Carrier frequency for CorteXlab USRP (Hz)
    value: float(__import__("os").environ.get("RF_FREQ", "434000000"))
  states: {}
- name: rx_gain
  id: variable
  parameters:
    comment: USRP RX Gain (dB)
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Sample rate = baud_rate * sps
    value: baud_rate * sps
  states: {}
- name: sensitivity
  id: variable
  parameters:
    comment: Modulator/Demodulator sensitivity (rad/sample)
    value: (2 * 3.141592653589793 * deviation) / samp_rate
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Samples per symbol
    value: '50'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    comment: USRP TX Gain (dB)
    value: '20'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    comment: RX Automatic Gain Control
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    comment: 1b. Band Pass Filter
    decim: '1'
    gain: '1'
    high_cutoff_freq: '15000'
    low_cutoff_freq: '-15000'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    comment: TX Frequency Shift (+freq_shift)
    freq: freq_shift
    sample_rate: samp_rate
  states: {}
- name: blocks_freqshift_cc_1
  id: blocks_freqshift_cc
  parameters:
    comment: RX Frequency Shift (-freq_shift)
    freq: '-freq_shift'
    sample_rate: samp_rate
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    comment: Trigger periodic PDU generation (1000 ms)
    msg: pmt.PMT_NIL
    period: '1000'
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    comment: Pack bytes to unpacked bits (8 to 1)
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    comment: Repack bits to bytes (1 to 8)
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '0.125'
    comment: Scale tag from bits to bytes (1/8)
    lengthtagname: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    comment: 2c. Tagged Stream Mux (Header + Payload)
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: Throttle for local test without USRP
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: bokehgui_waterfall_sink_x_0
  id: bokehgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    color: Inferno
    fc: '0'
    fftsize: '1024'
    grid: 'False'
    int_max: '10'
    int_min: '-140'
    label: ''
    legend: 'True'
    name: '""'
    placement: '[1, 1]'
    type: complex
    update_time: '100'
    wintype: window.WIN_BLACKMAN_hARRIS
    xlabel: Frequency
    xunit: Hz
    ylabel: Time
    yunit: ''
  states: {state: disabled}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    comment: RX DC Blocker (removes LO leakage spike)
    length: '1024'
    long_form: 'True'
    type: cc
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_code
    comment: 4a. Correlate Access Code - Tag Stream
    tagname: packet_len
    threshold: '0'
    type: byte
  states: {}
- name: digital_crc32_async_bb_0
  id: digital_crc32_async_bb
  parameters:
    check: 'False'
    comment: 2a. Append CRC32
  states: {}
- name: digital_crc32_async_bb_1
  id: digital_crc32_async_bb
  parameters:
    check: 'True'
    comment: 4d. Verify & Strip CRC32
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    comment: 3b. G3RUH Descrambler (1 + X^12 + X^17)
    len: '16'
    mask: '0x21001'
    seed: '0x20000'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_NRZI
    comment: 3a. Differential Decoder (NRZ-I)
    modulus: '2'
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_NRZI
    comment: 3b. Differential Encoder (NRZ-I)
    modulus: '2'
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    comment: 2. GFSK Demodulator (Quad Demod + Clock Recovery/Symbol Sync)
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: sps
    sensitivity: sensitivity
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: bt
    comment: 4a. GFSK Modulator 9600
    do_unpack: 'False'
    samples_per_symbol: sps
    sensitivity: sensitivity
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    comment: 2b. Protocol Formatter (Header + Length)
    format: hdr_format_tx
  states: {}
- name: digital_protocol_parser_b_0
  id: digital_protocol_parser_b
  parameters:
    comment: 4c. Protocol Parser (Length -> header_data)
    format: hdr_format_rx
  states: {state: disabled}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    comment: 3a. G3RUH Scrambler (1 + X^12 + X^17)
    len: '16'
    mask: '0x21001'
    seed: '0x20000'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Burst Tagger',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.length_tag_name = pmt.intern('packet_len')
              self.sob_key = pmt.intern('tx_sob')
              self.eob_key = pmt.intern('tx_eob')

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]
              n = len(in0)
              tags = self.get_tags_in_window(0, 0, n)
              for t in tags:
                  if pmt.symbol_to_string(t.key) == 'packet_len':
                      pkt_len = pmt.to_long(t.value)
                      self.add_item_tag(0, t.offset, self.sob_key, pmt.PMT_T)
                      self.add_item_tag(0, t.offset + pkt_len - 1, self.eob_key, pmt.PMT_T)
              out0[:n] = in0[:n]
              return n
    comment: Add tx_sob and tx_eob tags for USRP burst transmission
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    comment: 1. TX PDU Input (UDP Server)
    mtu: '10000'
    port: str(UDP_PORT_TX)
    type: UDP_SERVER
  states: {}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    comment: 4e. RX PDU Output (UDP Client to RADIANT)
    host: UDP_HOST_RX
    mtu: '10000'
    port: str(UDP_PORT_RX)
    type: UDP_CLIENT
  states: {}
- name: pdu_pdu_lambda_0
  id: pdu_pdu_lambda
  parameters:
    comment: Prepend 32 bytes of 0x55 preamble
    fn: 'lambda p: pmt.cons(pmt.car(p), pmt.init_u8vector(32 + len(pmt.u8vector_elements(pmt.cdr(p))), [0x55]*32 + list(pmt.u8vector_elements(pmt.cdr(p)))))'
    metadict: Raw Message
  states: {}
- name: pdu_pdu_lambda_1
  id: pdu_pdu_lambda
  parameters:
    comment: Append 64 bytes of 0x55 postamble to flush filters
    fn: 'lambda p: pmt.cons(pmt.car(p), pmt.init_u8vector(len(pmt.u8vector_elements(pmt.cdr(p))) + 64, list(pmt.u8vector_elements(pmt.cdr(p))) + [0x55]*64))'
    metadict: Raw Message
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header PDU -> Tagged Stream
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload PDU -> Tagged Stream
    tag: packet_len
    type: byte
  states: {}
- name: pdu_random_pdu_0
  id: pdu_random_pdu
  parameters:
    length_modulo: '8'
    mask: '0xFF'
    maxsize: '64'
    minsize: '8'
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    comment: Tagged Stream -> PDU
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: rf_freq
    comment: 4b. SDR Output
    gain0: tx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: rf_freq
    comment: 1a. SDR RX Source
    gain0: rx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc2_xx_0, '0', band_pass_filter_0, '0']
- [band_pass_filter_0, '0', bokehgui_waterfall_sink_x_0, '0']
- [band_pass_filter_0, '0', digital_gfsk_demod_0, '0']
- [band_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_throttle2_0, '0']
- [blocks_freqshift_cc_0, '0', uhd_usrp_sink_0, '0']
- [blocks_freqshift_cc_1, '0', analog_agc2_xx_0, '0']
- [blocks_message_strobe_0, strobe, pdu_random_pdu_0, generate]
- [blocks_repack_bits_bb_0, '0', digital_scrambler_bb_0, '0']
- [blocks_repack_bits_bb_1, '0', blocks_tagged_stream_multiply_length_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_mux_0, '0', epy_block_0, '0']
- [blocks_throttle2_0, '0', dc_blocker_xx_0, '0']
- [dc_blocker_xx_0, '0', blocks_freqshift_cc_1, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_crc32_async_bb_0, out, digital_protocol_formatter_async_0, in]
- [digital_crc32_async_bb_1, out, blocks_message_debug_1, print]
- [digital_crc32_async_bb_1, out, network_socket_pdu_1, pdus]
- [digital_descrambler_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_descrambler_bb_0, '0']
- [digital_diff_encoder_bb_0, '0', digital_gfsk_mod_0, '0']
- [digital_gfsk_demod_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_gfsk_mod_0, '0', blocks_freqshift_cc_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_lambda_0, pdu]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_lambda_1, pdu]
- [digital_scrambler_bb_0, '0', digital_diff_encoder_bb_0, '0']
- [epy_block_0, '0', blocks_repack_bits_bb_0, '0']
- [network_socket_pdu_0, pdus, digital_crc32_async_bb_0, in]
- [pdu_pdu_lambda_0, pdu, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_lambda_1, pdu, pdu_pdu_to_tagged_stream_1, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_1, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_random_pdu_0, pdus, blocks_message_debug_0, print_pdu]
- [pdu_random_pdu_0, pdus, digital_crc32_async_bb_0, in]
- [pdu_tagged_stream_to_pdu_0, pdus, digital_crc32_async_bb_1, in]
- [uhd_usrp_source_0, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
